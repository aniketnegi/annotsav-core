## main/Kconfig.projbuild
```kconfig
menu "Project INDRA Configuration"

    rsource "../components/wifi/Kconfig"
    
    rsource "../components/comms/Kconfig"

endmenu
```
